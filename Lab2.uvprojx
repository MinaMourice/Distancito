# Keil uVision project Lab2.uvprojx, settings and files
target HelloLaunchPad (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: HelloLaunchPad
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source
    ./: main.c startup.s foo.c foo.h
    C:/Users/Mina Mourice/Downloads/ezTivaLib/: ez123GLIB.lib
  group Object code
    ./: texas.o
software components: CMSIS:CORE 5.0.1
